Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-15T11:53:22
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Basic Wall:NBS_DeltaMembraneSystemsLtd_Polymer-modifiedCementitiousSlurries_KosterNB4000, Basic Wall:NBS_DeltaMembraneSystemsLtd_Polymer-modifiedCementitiousSlurries_KosterNB4000:222035
In: Level 0
Type - Material: NBS_DeltaMembraneSystemsLtd_Polymer-modifiedCementitiousSlurries_KosterNB4000 0.8 mm
Type - IFC - IfcExportAs: IfcCoveringType
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_31_53_66: Polymer-modified cementitious slurries; Color: n/a; Finish: n/a; Material: n/a; Shape: n/a; Size: n/a; WarrantyDescription: Ten year; CodePerformance: n/a; Constituents: n/a; Description: Two-component, mineral, thick film sealant. Quickly rain and waterproof.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Koster NB 4000; Name: Polymer-modifiedCementitiousSlurries_KosterNB4000_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_Polymer-modifiedCementitiousSlurries_KosterNB4000; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/2a9ea269-f3b5-1674-8ecf-503d2f73b7ce/41055321-dc1d-44de-ad2a-4c2debc3357d; Uniclass2015Code: Pr_20_31_53_66; Uniclass2015Title: Polymer-modified cementitious slurries; Uniclass2015Version: Products v1.35; Version: 8
Type - NBS_Data - ContainsRedListMaterials: No; Recyclability: No; RecycledContent: 0; Colour: Grey; ConsumptionPerLayerApplied: 3.1–4.2 kg/m²; SolidsContent: 90%; Density: 0.95 g/cm³; Temperature: 2–30°C
Classification: Pr_20_31_53_66 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_DeltaMembraneSystemsLtd_Polymer-modifiedCementitiousSlurries_KosterNB4000, Floor:NBS_DeltaMembraneSystemsLtd_Polymer-modifiedCementitiousSlurries_KosterNB4000:221889
In: Level 0
Type - Material: NBS_DeltaMembraneSystemsLtd_Polymer-modifiedCementitiousSlurries_KosterNB4000 0.8 mm
Type - IFC - IfcExportAs: IfcCoveringType
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_31_53_66: Polymer-modified cementitious slurries; Color: n/a; Finish: n/a; Material: n/a; Shape: n/a; Size: n/a; WarrantyDescription: Ten year; CodePerformance: n/a; Constituents: n/a; Description: Two-component, mineral, thick film sealant. Quickly rain and waterproof.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Koster NB 4000; Name: Polymer-modifiedCementitiousSlurries_KosterNB4000_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_Polymer-modifiedCementitiousSlurries_KosterNB4000; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/2a9ea269-f3b5-1674-8ecf-503d2f73b7ce/451b7b9f-0e22-471c-9a00-dc37fc5aa282; Uniclass2015Code: Pr_20_31_53_66; Uniclass2015Title: Polymer-modified cementitious slurries; Uniclass2015Version: Products v1.35; Version: 7
Type - NBS_Data - ContainsRedListMaterials: No; Recyclability: No; RecycledContent: 0; Colour: Grey; ConsumptionPerLayerApplied: 3.1–4.2 kg/m²; SolidsContent: 90%; Density: 0.95 g/cm³; Temperature: 2–30°C
Classification: Pr_20_31_53_66 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
